# Keil uVision project 2023_Hero_gimbal.uvprojx, settings and files
target 2023_Hero_gimbal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2023_Hero_gimbal.axf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --gnu --diag_suppress=1,3108,1035
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/motion_fx;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../U5erC0de;../U5erC0de/base_drv/drv_imu;../U5erC0de/base_drv;../U5erC0de/base_drv/graphic
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/motion_fx
    ../Middlewares/motion_fx/: motion_fx_manager.c motion_fx.lib MotionFX_CM4F_wc16_ot.lib
  group alogrithm
    ../U5erC0de/algorithm/: ballistic.c ballistic.h cordic.c cordic.h filter.c filter.h pid.c pid.h pid_ladrc.c pid_ladrc.h pid_leso.c pid_leso.h util.h crc.c crc.h zero_new_bee_filter.c zero_new_bee_filter.h
  group base_drv
    ../U5erC0de/base_drv/: drv_can.c drv_can.h drv_conf.h drv_uart.c drv_uart.h power_ctrl.c power_ctrl.h
    ../U5erC0de/base_drv/graphic/: drv_graphic.h graphic_def.h drv_graphic.c graphic_draw.c
  group drv_imu
    ../U5erC0de/base_drv/drv_imu/: bmi08a.c bmi08g.c bmi08x.h bmi08x_defs.h drv_bmi088.c drv_bmi088.h imu_bmi088.c imu_bmi088.h imu_calibrate.c imu_calibrate.h imu_dcm.c imu_dcm.h imu_fusion.h imu.c imu.h
  group drv_motor
    ../U5erC0de/base_drv/drv_motor/: motor.c motor.h motor_ctrl.c motor_ctrl.h motor_lib.c motor_lib.h
  group drv_rc
    ../U5erC0de/base_drv/drv_rc/: rc.c rc.h
  group drv_buzzer
    ../U5erC0de/base_drv/drv_buzzer/: buzzer.c buzzer.h
  group interface
    ../U5erC0de/robot_core/interface/: interface_BTB.c interface_BTB.h interface_BTB_distributor.c
  group weapon
    ../U5erC0de/robot_core/weapon/: shooter.c shooter.h vision.c vision.h fire_ctrl_param.h fire_ctrl.c
  group tool
    ../U5erC0de/robot_core/tool/: bus_detect.c bus_detect.h vofa.c vofa.h
  group robot_core
    ../U5erC0de/robot_core/ctrl_core/: gimbal.c gimbal.h gimbal_motor_ctrl.c gimbal_motor_ctrl.h robot.c robot.h chassis_motor_ctrl.c chassis.c chassis.h chassis_motor_ctrl.h move_ctrl.h move_ctrl.c
    ../U5erC0de/robot_core/weapon/: dial.c dial.h
    ../U5erC0de/base_drv/drv_cap/: super_cap.c super_cap.h
  group tool/uitls
    ../U5erC0de/robot_core/tool/utils/: mem_log.c mem_log.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h trice.c trice.h triceConfig.h
  group New Group
    ../U5erC0de/base_drv/drv_referee/: referee.c referee.h referee_conf.h referee_conf_2018.h referee_conf_2023.h
software components: CMSIS:CORE 5.6.0
